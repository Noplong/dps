# IAR project DDH5267.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_HD_VL; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: cpu; app; driver\src; driver\inc; Atomthreads
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: DDH5269new.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app
    app/: Current.c Current.h FLASH.c FLASH.h GPRS.c GPRS.h IOCheck.c IOCheck.h lcd.c lcd.h LedBeepKey.c LedBeepKey.h main.c MixChannel.c MixChannel.h SysUsart.c SysUsart.h Window.c
  group Atomthreads
    Atomthreads/: atom.h atomkernel.c atommutex.c atommutex.h atomport-asm-iar.s atomport-private.h atomport-template.h atomport.c atomport.h atomqueue.c atomqueue.h atomsem.c atomsem.h atomtimer.c atomtimer.h stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h uart.c uart.h
  group cpu
    cpu/: stm8l15x_conf.h stm8l15x_it.h
  group driver
    driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
